options:
  parameters:
    generate_options: qt_gui
    id: dalek
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: diode
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '.001'
    stop: '.7'
    value: '.050'
  states: {}
- name: modfreq
  id: variable_qtgui_range
  parameters:
    label: Modulation Frequency
    start: '0'
    step: '1'
    stop: '200'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '11000'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '0.25'
    type: float
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '1'
    lo: '-1'
  states: {}
- name: analog_rail_ff_0_0
  id: analog_rail_ff
  parameters:
    hi: '1'
    lo: diode
  states: {}
- name: analog_rail_ff_0_1
  id: analog_rail_ff
  parameters:
    hi: '-diode'
    lo: '-1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: modfreq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\Steven\Downloads\kip-withbabe.wav
    repeat: 'False'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    size: '10000'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_multiply_xx_0, '0']
- [analog_agc_xx_0, '0', blocks_multiply_xx_1, '0']
- [analog_rail_ff_0, '0', audio_sink_0, '0']
- [analog_rail_ff_0, '0', qtgui_time_sink_x_0, '0']
- [analog_rail_ff_0_0, '0', blocks_add_xx_0, '0']
- [analog_rail_ff_0_1, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_1, '1']
- [blocks_add_xx_0, '0', analog_rail_ff_0, '0']
- [blocks_multiply_xx_0, '0', analog_rail_ff_0_0, '0']
- [blocks_multiply_xx_1, '0', analog_rail_ff_0_1, '0']
- [blocks_wavfile_source_0, '0', analog_agc_xx_0, '0']

metadata:
  file_format: 1
