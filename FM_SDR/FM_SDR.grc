options:
  parameters:
    generate_options: qt_gui
    id: Options
    output_language: python
    title: FM SDR Receiver
  states: {}

blocks:
- name: cutoff
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '99090000'
  states: {}
- name: freqsel
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: '87000000'
    step: '10000'
    stop: '109000000'
    value: '99090000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '.01'
    stop: '1'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: trans
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: '500000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff
    decim: int(samp_rate/500e3)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: trans
    win: window.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '500'
    interp: '48'
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: freqsel
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
